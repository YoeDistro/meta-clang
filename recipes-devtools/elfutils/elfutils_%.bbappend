RDEPENDS:${PN}-ptest:append:toolchain-clang = " clang"
